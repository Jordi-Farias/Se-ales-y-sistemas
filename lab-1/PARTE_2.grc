options:
  parameters:
    author: j
    generate_options: qt_gui
    id: PARTE_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: n_decim
  id: variable_qtgui_chooser
  parameters:
    label0: 1/3
    label1: 1/6
    label2: 1/12
    num_opts: '3'
    option0: '3'
    option1: '6'
    option2: '12'
    type: real
    value: '3'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia de muestreo '
    start: '24000'
    step: '1'
    stop: '96000'
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: n_decim
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*3
    type: float
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate / n_decim
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/j/Documentos/SyS Lab/lab-1/muestras_guitarra/acoustic.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/j/Documentos/SyS Lab/lab-1/muestras_guitarra/acoustic.wav
    repeat: 'True'
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '3'
    taps: '[1,0,0]'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"señal 2 ceros"'
    size: '2048'
    srate: samp_rate*3
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"señal decimada"'
    size: '512'
    srate: samp_rate / n_decim
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"punto 1"'
    size: '2048'
    srate: '44100'
    type: float
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', blocks_throttle2_0_0_0_0, '0']
- [blocks_throttle2_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle2_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_wavfile_source_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_throttle2_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
